Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: RdM vs2
Time: 2022-10-12T09:11:10
Made in: IfcPlusPlus

# IfcSite: Surface terrain, Terrain
Description: Surface 3D : Terrain; Group: Surfaces 3D
PSET-MENSURA - Nom Surface MNT: Terrain; Surface Horizontale: 2844.81 m2; Surface Selon la pente: 2897.51 m2; Valeur décapage par défaut: 0 m
IfcElementQuantity - Surface Horizontale: 2844.81 m2; Surface Selon la pente: 2897.51 m2; Valeur décapage par défaut: 0 m

# IfcFlowFitting
In: Extérieur (Terrain)
PSET-MENSURA - Numéro: P8bis; Type de Noeud: Culotte 87°; X: 1838671 m; Y: 4173770 m; Z Surface: 90.0296 m; Catalogue Fourniture: Noeuds Détaillés MENSURA 2020; Gamme: Gamme
Group: EU; Réseaux EU

# IfcFlowFitting: Regard et noeud d'assainissement (47)
In: Extérieur (Terrain)
PSET-MENSURA - Catalogue Fourniture: Noeuds Détaillés MENSURA 2020
Name | Description | Numéro | Type de regard | X (m) | Y (m) | PSET-MENSURA, Profondeur (m) = IfcElementQuantity, Profondeur (m) | URL | Group | Elément droit
R.EPL6 - Dalle de réduction | EP | R.EPL6 | RV béton Ø800 | 1838631 | 4173831 | 1.64086 | http:// | EP; EP | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150
R.EPL6 - Couvercle | EP | R.EPL6 | RV béton Ø800 | 1838631 | 4173831 | 1.64086 | http:// | EP; EP | PSET-MENSURA - Tampon: Regard Ø600 D400; PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte
R.EPL6 - Elément droit | EP | R.EPL6 | RV béton Ø800 | 1838631 | 4173831 | 1.64086 | http:// | EP; EP | EDRT Ø800_900
R.EPL6 - Fond | EP | R.EPL6 | RV béton Ø800 | 1838631 | 4173831 | 1.64086 | http:// | EP; EP | EDRT Ø800_900 | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150; Tampon: Regard Ø600 D400; Z tampon: 89.7409 m; Zfe 1: 88.1 m; Zfe 2: 88.1 m; Elément de fond: EFD Ø800_400; Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m; Cunette: CUN ES 1ent/1sorti; IfcElementQuantity - Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m
R.EPL5 - Dalle de réduction | EP | R.EPL5 | RV béton Ø800 | 1838610 | 4173869 | 1.83755 | http:// | EP; EP | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150
R.EPL5 - Couvercle | EP | R.EPL5 | RV béton Ø800 | 1838610 | 4173869 | 1.83755 | http:// | EP; EP | PSET-MENSURA - Tampon: Regard Ø600 D400; PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte
R.EPL5 - Elément droit | EP | R.EPL5 | RV béton Ø800 | 1838610 | 4173869 | 1.83755 | http:// | EP; EP | EDRT Ø800_900
R.EPL5 - Fond | EP | R.EPL5 | RV béton Ø800 | 1838610 | 4173869 | 1.83755 | http:// | EP; EP | EDRT Ø800_900 | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150; Tampon: Regard Ø600 D400; Z tampon: 89.7675 m; Zfe 1: 87.93 m; Zfe 2: 87.93 m; Elément de fond: EFD Ø800_400; Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m; Cunette: CUN ES 1ent/1sorti; IfcElementQuantity - Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m
R.EPL7 - Dalle de réduction | EP | R.EPL7 | RV béton Ø800 | 1838647 | 4173799 | 1.70072 | http:// | EP; EP | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150
R.EPL7 - Couvercle | EP | R.EPL7 | RV béton Ø800 | 1838647 | 4173799 | 1.70072 | http:// | EP; EP | PSET-MENSURA - Tampon: Regard Ø600 D400; PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte
R.EPL7 - Elément droit | EP | R.EPL7 | RV béton Ø800 | 1838647 | 4173799 | 1.70072 | http:// | EP; EP | EDRT Ø800_900
R.EPL7 - Fond | EP | R.EPL7 | RV béton Ø800 | 1838647 | 4173799 | 1.70072 | http:// | EP; EP | EDRT Ø800_900 | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150; Tampon: Regard Ø600 D400; Z tampon: 89.9507 m; Zfe 1: 88.25 m; Zfe 2: 88.25 m; Elément de fond: EFD Ø800_400; Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m; Cunette: CUN ES 1ent/1sorti; IfcElementQuantity - Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m
R.EPL8 - Fond | EP | R.EPL8 | RV béton Ø1000 | 1838664 | 4173769 | 1.62 |  | EP; EP | PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte; PSET-MENSURA - Z tampon: 90.01 m; Zfe 1: 88.39 m; Zfe 2: 88.9 m; Hauteur Elément de fond: 0 m; Hauteur de décantation: 0 m; Zfe 3: 88.9 m; IfcElementQuantity - Hauteur Elément de fond: 0 m; Hauteur de décantation: 0 m
R.EPL10 - Fond | EP | R.EPL10 | RV béton Ø800 | 1838701 | 4173768 | 1.24 | http:// | EP; EP | PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte; PSET-MENSURA - Z tampon: 90.43 m; Zfe 1: 89.19 m; Zfe 2: 89.19 m; Hauteur Elément de fond: 0 m; Hauteur de décantation: 0 m; IfcElementQuantity - Hauteur Elément de fond: 0 m; Hauteur de décantation: 0 m
R.EPL11 - Fond | EP | R.EPL11 | RV béton Ø1000 | 1838737 | 4173768 | 1.4 |  | EP; EP | PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte; PSET-MENSURA - Z tampon: 90.87 m; Zfe 1: 89.47 m; Hauteur Elément de fond: 0 m; Hauteur de décantation: 0 m; IfcElementQuantity - Hauteur Elément de fond: 0 m; Hauteur de décantation: 0 m
R.EPL14 - Dalle de réduction | EP | R.EPL14 | RV béton Ø800 | 1838649 | 4173763 | 1.41 | http:// | EP; EP | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150
R.EPL14 - Couvercle | EP | R.EPL14 | RV béton Ø800 | 1838649 | 4173763 | 1.41 | http:// | EP; EP | PSET-MENSURA - Tampon: Regard Ø600 D400; PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte
R.EPL14 - Elément droit | EP | R.EPL14 | RV béton Ø800 | 1838649 | 4173763 | 1.41 | http:// | EP; EP | EDRT Ø800_600
R.EPL14 - Fond | EP | R.EPL14 | RV béton Ø800 | 1838649 | 4173763 | 1.41 | http:// | EP; EP | EDRT Ø800_600 | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150; Tampon: Regard Ø600 D400; Z tampon: 89.85 m; Zfe 1: 88.44 m; Zfe 2: 88.44 m; Elément de fond: EFD Ø800_400; Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m; Cunette: CUN ES 1ent/1sorti; IfcElementQuantity - Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m
REU4 - Dalle de réduction | EU | REU4 | RV béton Ø800 | 1838611 | 4173870 | 2.71684 | http:// | EU; EU | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150
REU4 - Couvercle | EU | REU4 | RV béton Ø800 | 1838611 | 4173870 | 2.71684 | http:// | EU; EU | PSET-MENSURA - Tampon: Regard Ø600 D400; PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte
2 x REU4 - Elément droit | EU | REU4 | RV béton Ø800 | 1838611 | 4173870 | 2.71684 | http:// | EU; EU | EDRT Ø800_900 EDRT Ø800_900
REU4 - Fond | EU | REU4 | RV béton Ø800 | 1838611 | 4173870 | 2.71684 | http:// | EU; EU | EDRT Ø800_900 EDRT Ø800_900 | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150; Tampon: Regard Ø600 D400; Z tampon: 89.7768 m; Zfe 1: 87.06 m; Zfe 2: 87.06 m; Elément de fond: EFD Ø800_400; Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m; Cunette: CUN ES 1ent/1sorti; IfcElementQuantity - Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m
REU5 - Dalle de réduction | EU | REU5 | RV béton Ø800 | 1838631 | 4173832 | 2.4454 | http:// | EU; EU | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150
REU5 - Couvercle | EU | REU5 | RV béton Ø800 | 1838631 | 4173832 | 2.4454 | http:// | EU; EU | PSET-MENSURA - Tampon: Regard Ø600 D400; PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte
2 x REU5 - Elément droit | EU | REU5 | RV béton Ø800 | 1838631 | 4173832 | 2.4454 | http:// | EU; EU | EDRT Ø800_600 EDRT Ø800_900
REU5 - Fond | EU | REU5 | RV béton Ø800 | 1838631 | 4173832 | 2.4454 | http:// | EU; EU | EDRT Ø800_600 EDRT Ø800_900 | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150; Tampon: Regard Ø600 D400; Z tampon: 89.7454 m; Zfe 1: 87.3 m; Zfe 2: 87.3 m; Elément de fond: EFD Ø800_400; Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m; Cunette: CUN ES 1ent/1sorti; IfcElementQuantity - Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m
REU6 - Dalle de réduction | EU | REU6 | RV béton Ø800 | 1838648 | 4173800 | 2.46163 | http:// | EU; EU | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150
REU6 - Couvercle | EU | REU6 | RV béton Ø800 | 1838648 | 4173800 | 2.46163 | http:// | EU; EU | PSET-MENSURA - Tampon: Regard Ø600 D400; PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte
2 x REU6 - Elément droit | EU | REU6 | RV béton Ø800 | 1838648 | 4173800 | 2.46163 | http:// | EU; EU | EDRT Ø800_900 EDRT Ø800_900
REU6 - Fond | EU | REU6 | RV béton Ø800 | 1838648 | 4173800 | 2.46163 | http:// | EU; EU | EDRT Ø800_900 EDRT Ø800_900 | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150; Tampon: Regard Ø600 D400; Z tampon: 89.9516 m; Zfe 1: 87.49 m; Zfe 2: 87.49 m; Elément de fond: EFD Ø800_400; Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m; Cunette: CUN ES 1ent/1sorti; IfcElementQuantity - Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m
REU7 - Fond | EU | REU7 | RV béton Ø1000 | 1838664 | 4173770 | 2.31 |  | EU; EU | PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte; PSET-MENSURA - Z tampon: 89.99 m; Zfe 1: 87.68 m; Zfe 2: 87.68 m; Hauteur Elément de fond: 0 m; Hauteur de décantation: 0 m; IfcElementQuantity - Hauteur Elément de fond: 0 m; Hauteur de décantation: 0 m
REU10 - Fond | EU | REU10 | RV béton Ø1000 | 1838736 | 4173768 | 2.83 |  | EU; EU | PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte; PSET-MENSURA - Z tampon: 90.87 m; Zfe 1: 88.04 m; Hauteur Elément de fond: 0 m; Hauteur de décantation: 0 m; IfcElementQuantity - Hauteur Elément de fond: 0 m; Hauteur de décantation: 0 m
REU9 - Dalle de réduction | EU | REU9 | RV béton Ø800 | 1838701 | 4173769 | 2.57 | http:// | EU; EU | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150
REU9 - Couvercle | EU | REU9 | RV béton Ø800 | 1838701 | 4173769 | 2.57 | http:// | EU; EU | PSET-MENSURA - Tampon: Regard Ø600 D400; PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte
2 x REU9 - Elément droit | EU | REU9 | RV béton Ø800 | 1838701 | 4173769 | 2.57 | http:// | EU; EU | EDRT Ø800_900 EDRT Ø800_900
REU9 - Fond | EU | REU9 | RV béton Ø800 | 1838701 | 4173769 | 2.57 | http:// | EU; EU | EDRT Ø800_900 EDRT Ø800_900 | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150; Tampon: Regard Ø600 D400; Z tampon: 90.43 m; Zfe 1: 87.86 m; Zfe 2: 87.86 m; Elément de fond: EFD Ø800_400; Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m; Cunette: CUN ES 1ent/1sorti; IfcElementQuantity - Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m
REU8 - Dalle de réduction | EU | REU8 | RV béton Ø800 | 1838668 | 4173770 | 2.32368 | http:// | EU; EU | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150
REU8 - Couvercle | EU | REU8 | RV béton Ø800 | 1838668 | 4173770 | 2.32368 | http:// | EU; EU | PSET-MENSURA - Tampon: Regard Ø600 D400; PSET - Attributs Mensura - Dimension: Ø 600; Matériaux: Fonte
2 x REU8 - Elément droit | EU | REU8 | RV béton Ø800 | 1838668 | 4173770 | 2.32368 | http:// | EU; EU | EDRT Ø800_600 EDRT Ø800_900
REU8 - Fond | EU | REU8 | RV béton Ø800 | 1838668 | 4173770 | 2.32368 | http:// | EU; EU | EDRT Ø800_600 EDRT Ø800_900 | PSET-MENSURA - Dalle de réduction: DALRED Ø800_150; Tampon: Regard Ø600 D400; Z tampon: 90.0247 m; Zfe 1: 87.701 m; Zfe 2: 87.701 m; Elément de fond: EFD Ø800_400; Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m; Cunette: CUN ES 1ent/1sorti; IfcElementQuantity - Hauteur Elément de fond: 0.4 m; Hauteur de décantation: 0 m
REU11 - Fond | EU | REU11 | Ø315 | 1838671 | 4173775 | 2.23755 |  | EU; EU | PP10 Ø315 | PSET-MENSURA - Tampon: tampon fonte B125; Z tampon: 90.0325 m; Zfe 1: 87.795 m; Elément de fond: PP Ø315/110; Hauteur Elément de fond: 0.18 m; Hauteur de décantation: 0 m; Cunette: Non; IfcElementQuantity - Hauteur Elément de fond: 0.18 m; Hauteur de décantation: 0 m

# IfcFlowSegment: Collecteur d'assainissement (16)
In: Extérieur (Terrain)
PSET-MENSURA - Type Collecteur: Circulaire; Longueur Hors tout: 0 m; Rugosité : Coef Manning Stickler: 80; Surface de référence: Aucune; Fouille: Aucune; Référence imposée: Non; Tronçon existant: Non
IfcElementQuantity - Longueur Hors tout: 0 m
Name (Tronçon :...) | Description = Type de réseaux | Regard/Noeud Amont | Regard/Noeud Aval | Gamme | Diamètre de référence (mm) (mm) | PSET-MENSURA, Longueur tronçon (m) = IfcElementQuantity, Longueur tronçon (m) | Pente % | Diamètre intérieur (mm) | PSET-MENSURA, Epaisseur collecteur (m) = IfcElementQuantity, Epaisseur collecteur (m) | PSET-MENSURA, Longueur utile (m) = IfcElementQuantity, Longueur utile (m) | PSET-MENSURA, Poids (kg) (kg) = IfcElementQuantity, Poids (kg) (kg) | Diamètre Forage (mm) | Rugosité : Coef de Bazin | Rugosité : Coef Colebrook White | Group
 R.EPL6 - R.EPL5 | EP | R.EPL6 | R.EPL5 | BETON 135A | 300 | 42.4316 | 0.400648 | 300 | 0.044 | 3 | 360 | 306 | 0.25 | 2.44 | EP; EP
 R.EPL7 - R.EPL6 | EP | R.EPL7 | R.EPL6 | BETON 135A | 300 | 36.2692 | 0.413578 | 300 | 0.044 | 3 | 360 | 306 | 0.25 | 2.44 | EP; EP
 R.EPL8 - R.EPL7 | EP | R.EPL8 | R.EPL7 | BETON 135A | 500 | 34.5664 | 1.88077 | 500 | 0.053 | 3 | 600 | 510 | 0.25 | 2.44 | EP; EP
 R.EPL10 - R.EPL8 | EP | R.EPL10 | R.EPL8 | BETON 135A | 400 | 37.6539 | 0.770196 | 400 | 0.045 | 3 | 480 | 408 | 0.25 | 2.44 | EP; EP
 R.EPL11 - R.EPL10 | EP | R.EPL11 | R.EPL10 | BETON 135A | 400 | 35.7211 | 0.783875 | 400 | 0.045 | 3 | 480 | 408 | 0.25 | 2.44 | EP; EP
 R.EPL14 - R.EPL8 | EP | R.EPL14 | R.EPL8 | BETON 135A | 300 | 15.8484 | 0.315491 | 300 | 0.044 | 3 | 360 | 306 | 0.25 | 2.44 | EP; EP
 R.EPL13 - R.EPL14 | EP | R.EPL13 | R.EPL14 | BETON 135A | 300 | 51.6344 | 0.309873 | 300 | 0.044 | 3 | 360 | 306 | 0.25 | 2.44 | EP; EP
 R.EPL5 - R.EPL4 | EP | R.EPL5 | R.EPL4 | BETON 135A | 300 | 49.3608 | 0.405183 | 300 | 0.044 | 3 | 360 | 306 | 0.25 | 2.44 | EP; EP
 REU4 - REU3 | EU | REU4 | REU3 | GRES | 200 | 49.3984 | 0.526807 | 200 | 0.02 | 2 | 74 | 0 | 0.06 | 0.54 | EU; EU
 REU5 - REU4 | EU | REU5 | REU4 | GRES | 200 | 42.5835 | 0.563607 | 200 | 0.02 | 2 | 74 | 0 | 0.06 | 0.54 | EU; EU
 REU6 - REU5 | EU | REU6 | REU5 | GRES | 200 | 36.1579 | 0.525481 | 200 | 0.02 | 2 | 74 | 0 | 0.06 | 0.54 | EU; EU
 REU7 - REU6 | EU | REU7 | REU6 | GRES | 200 | 33.9087 | 0.560337 | 200 | 0.02 | 2 | 74 | 0 | 0.06 | 0.54 | EU; EU
 REU10 - REU9 | EU | REU10 | REU9 | GRES | 200 | 35.4946 | 0.507125 | 200 | 0.02 | 2 | 74 | 0 | 0.06 | 0.54 | EU; EU
 REU9 - REU8 | EU | REU9 | REU8 | GRES | 200 | 32.4992 | 0.489147 | 200 | 0.02 | 2 | 74 | 0 | 0.06 | 0.54 | EU; EU
 REU8 - REU7 | EU | REU8 | REU7 | GRES | 200 | 4.30005 | 0.489147 | 200 | 0.02 | 2 | 74 | 0 | 0.06 | 0.54 | EU; EU
 REU11 - | EU | REU11 | Non disponible | PVC CR-SN8 | 160 | 5.20026 | 1 | 146 | 0.007 | 3 | 0 | 0 | 0.06 | 0.54 | EU; EU

# IfcGroup (7)
Name | Group
Terrains
Terrain | Terrains
Surfaces 3D | Terrain
Réseaux d'assainissement
EP | Réseaux d'assainissement
EU | Réseaux d'assainissement
Réseaux EU | Réseaux d'assainissement
